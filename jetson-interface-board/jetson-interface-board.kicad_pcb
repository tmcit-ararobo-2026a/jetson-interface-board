# Repository tmcit-ararobo-2026a/jetson-interface-board

File README.md:

# Jetson Interface Board

Jetson Orin Nano (Super)の`button header`や`GPIO`に接続してCAN通信やUSB type-Cによるシリアルコンソールアクセス、RTCクロック(DS3231)の接続を可能にする基板

## 目次

1. [概要](#1-概要)
2. [ドキュメント](#2-ドキュメント)
3. [ビルド・使い方](#3-ビルド使い方)
4. [システム構成](#4-システム構成)
5. [ライセンス](#5-ライセンス)

## 1. 概要

Jetson Orin Nano Developer Packには多様なインターフェイスが接続可能であるが、CAN通信やシリアルコンソール、RTCクロックなどの接続には外部の追加回路が必要となる。
追加回路をジャンパー線などで簡易的に作成することも可能だが、安定性に懸念がある。
そこで、基板を作成した。

## 2. ドキュメント

| ドキュメント | 説明 |
| :-: | :-: |
| [CONTRIBUTING.md](./CONTRIBUTING.md) | 開発フロー・コミット規約・コーディング規約 |
| [docs/coding-rules.md](./docs/coding-rules.md) | コーディング規約の詳細 |
| [docs/uml/](./docs/uml/) | UML図 |

## 3. 使い方

<!-- ビルドのやり方 -->
<!-- 使い方 -->

## 4. システム構成

<!-- ROS2ノード構成・STM32との通信方式・ハードウェア構成 等 -->
<!-- 依存クラスが3つ以上ある場合は docs/uml/ にUML図を作成し、ここにリンクする -->

## 5. ライセンス

本リポジトリは [MITライセンス](./LICENSE) のもとで公開されています。

## KiCad design jetson-interface-board/jetson-interface-board.kicad_pcb

Parts:
C1, C2, C4: 0.1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6: 4.7uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8, C9: 1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D3, D4, D5, D6: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J2: Conn_01x04; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J3: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J4: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J5: Conn_01x18; PinSocket_1x18_P2.54mm_Horizontal
JP1: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
R1: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R6, R7, R8, R9, R10: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: MCP2562-E-MF; DFN-8-1EP_3x3mm_P0.65mm_EP1.55x2.4mm
U2: FT234XD; WDFN-12-1EP_3x3mm_P0.45mm_EP1.7x2.5mm
U3: XC8111AA01MR-G; SOT-23-5

Connections:
3.3V_FT: C6.1, R1.1, R4.2, R7.2, U2.3 (3V3OUT), U2.9 (VCCIO); also elsewhere on the board
+3.3V: C1.1, J5.15, R10.2, U1.5 (Vio)
+5V: C2.1, C9.1, J4.3, R9.2, U1.3 (VDD), U3.5 (OUT)
+5VP: C8.1, J1.3, J2.3, R8.2, U3.1 (IN), U3.3 (CE)
CANH: J1.4, J2.4, JP1.2 (B), U1.7 (CANH)
CANL: J1.2, J2.2, R5.2, U1.6 (CANL)
CAN_RX: J5.17, U1.4 (RXD)
CAN_TX: J5.18, U1.1 (TXD)
GNDD: C1.2, C2.2, C4.2, C6.2, C7.2, C8.2, C9.2, D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), J1.1, J2.1, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J4.1, J5.2, J5.4, J5.6, J5.16, R2.2, R3.2, U1.2 (VSS), U1.8 (SHDN), U1.9 (PAD), U2.5 (GND), U2.13 (GND), U3.2 (GND); also elsewhere on the board
unnamed: D1.2 (A), R4.1
unnamed: D1.1 (K), U2.6 (CBUS0)
unnamed: D2.2 (A), R6.1
unnamed: D3.2 (A), R7.1
unnamed: D4.2 (A), R8.1
unnamed: D5.2 (A), R9.1
unnamed: D6.2 (A), R10.1
unnamed: J3.A5 (CC1), R3.1
unnamed: J3.B5 (CC2), R2.1
unnamed: JP1.1 (A), R5.1
unnamed: R1.2, U2.2 (~RESET)
UART_RX: J5.10, U2.7 (TXD/D0)
UART_TX: J5.9, U2.10 (RXD/D1)
USBD+: J3.A6 (D+), J3.B6 (D+), U2.12 (USBDP)
USBD-: J3.A7 (D-), J3.B7 (D-), U2.1 (USBDM)
VBUS: C4.1, C7.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), R6.2, U2.4 (VCC)

Notes on the sheet:
LED
jetson 接続端子
CAN
バックアップ電源用 理想ダイオード
USB serial

Board: 2 copper layers, 63.0 x 23.0 mm, 33 parts (0 on the bottom side), 25 nets.

Other parts of the board:
C3: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder

Their connections:
3.3V_FT: C3.1; also elsewhere on the board
GNDD: C3.2; also elsewhere on the board

File jetson-interface-board/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C4",0603,3,0.1uf,
"C3, C7",0603,2,0.1u,
C6,0603,1,4.7uf,
"C8, C9",0603,2,1uf,
"D1, D2, D3, D4, D5, D6",0603,6,LED,
"J1, J2",JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,2,Conn_01x04,
J3,USB_C_Receptacle_HRO_TYPE-C-31-M-12,1,USB_C_Receptacle_USB2.0,
J4,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,1,Conn_01x04,
J5,PinSocket_1x18_P2.54mm_Horizontal,1,Conn_01x18,
JP1,PinHeader_1x02_P2.54mm_Vertical,1,Jumper_2_Open,
R1,0603,1,10k,
"R10, R4, R6, R7, R8, R9",0603,6,1k,
"R2, R3",0603,2,4.7k,
R5,0603,1,120,
U1,DFN-8-1EP_3x3mm_P0.65mm_EP1.55x2.4mm,1,MCP2562-E-MF,
U2,WDFN-12-1EP_3x3mm_P0.45mm_EP1.7x2.5mm,1,FT234XD,
U3,SOT-23-5,1,XC8111AA01MR-G,

## KiCad design jetson-rtc/jetson-rtc.kicad_pcb

Parts:
C1, C2: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: CR2032; CH243-2032LF
D1, D2: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J2: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical
R1, R2: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_Push; switch_TVAF06-A020B-R
U1: DS3231MZ; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C1.1, J2.1, R2.2, U1.2 (VCC)
+5V: J1.3, J2.2, J2.4, R1.2
+BATT: C2.1, C3.1, U1.6 (VBAT)
GNDD: C1.2, C2.2, C3.2, D1.1 (K), D2.1 (K), J1.1, J2.6, J2.9, J2.14, J2.20, J2.25, J2.30, J2.34, J2.39, SW1.1, U1.5 (GND)
I2C1_SCL: J2.5, U1.8 (SCL)
I2C1_SDA: J2.3, U1.7 (SDA)
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R2.1
unnamed: SW1.2, U1.4 (~RST)

Notes on the sheet:
LED
rtc

Board: 2 copper layers, 13.0 x 52.0 mm, 11 parts (1 on the bottom side), 9 nets.

File jetson-rtc/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2",0603,2,0.1u,
C3,CH243-2032LF,1,CR2032,
"D1, D2",0603,2,LED,
J1,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,1,Conn_01x04,
J2,PinSocket_2x20_P2.54mm_Vertical,1,Conn_02x20_Odd_Even,
"R1, R2",0603,2,1k,
SW1,switch_TVAF06-A020B-R,1,SW_Push,
U1,SOIC-8_3.9x4.9mm_P1.27mm,1,DS3231MZ,

## Commit log

2026-04-27 12+4 PIN側回路図完成
2026-04-28 jetson-interface-board ビア以外完成
2026-04-28 jetson-rtc ビア以外完成
2026-04-28 回路図清掃
2026-05-02 ビア打ち、シルク、ガーバ生成
2026-05-03 feat:インジケータとスイッチ変更および再配線・再配置
2026-05-03 add:garber
2026-05-20 fix:[WIP]pin header
2026-05-21 feat:route all nets
2026-05-25 配線修正 ガーバー出力
2026-05-31 docs: update README
    Updated project description and usage section in README.
